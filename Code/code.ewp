# IAR project code.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: D:\ASU\4-Senior1\Fall 23\CSE211 Introduction to Embedded Systems\Tivaware
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: D:\ASU\4-Senior1\Fall 23\CSE211 Introduction to Embedded Systems\Tivaware\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group HAL/SMOKE_SENSOR
    HAL/SMOKE_SENSOR/: smoke_sensor.c smoke_sensor.h
  group HAL/ULTRASONIC_SENSOR
    HAL/ULTRASONIC_SENSOR/: ultrasonic_sensor.c ultrasonic_sensor.h
  group INC
    INC/: bitwiseOperations.h cortexM4.h startup_ewarm.c tm4c123gh6pm.h types.h
  group MCAL/GPIO
    MCAL/GPIO/: gpio.c gpio.h
  group MCAL/SYSTICK
    MCAL/SYSTICK/: sysTick.c sysTick.h
  group MCAL/TIMER
    MCAL/TIMER/: timer.c timer.h
  group MCAL/UART
    MCAL/UART/: uart.c uart.h
